# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c LCD1602.c LCD1602.h MatrixKey.c MatrixKey.h Timer0.c Timer0.h Key.c Key.h Timer1.c Timer1.h DS18B20.c DS18B20.h OneWrie.c OneWrie.h XPT2406.c XPT2406.h
